# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F091xC, USE_HAL_DRIVER
  c include: .;..\..\rt-thread\include;applications;.;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m0;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\finsh;..\libraries\STM32F0xx_HAL\CMSIS\Device\ST\STM32F0xx\Include;..\libraries\STM32F0xx_HAL\STM32F0xx_HAL_Driver\Inc;..\libraries\STM32F0xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f0xx_hal_msp.c
    ../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f091xc.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group cpu
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group STM32_HAL
    ../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../libraries/STM32F0xx_HAL/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_ll_crc.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_utils.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_ll_usart.c
